# IAR project bldc_foc.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: HPM6750xVMx HPMicro HPM6750xVMx
  General.GHeapSize: 0x4000
  ICCRISCV.IccLang: 2
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCExtraOptions: --diag_suppress Pa089; --diag_suppress Pe236; --diag_suppress Pe188; --diag_suppress Pe546; --diag_suppress Pe111
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_MULTICORE=y; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_ADC12=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_CAN=y; HPMSOC_HAS_HPMSDK_WDG=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMA=y; HPMSOC_HAS_HPMSDK_RNG=y; HPMSOC_HAS_HPMSDK_KEYM=y; HPMSOC_HAS_HPMSDK_I2S=y; HPMSOC_HAS_HPMSDK_DAO=y; HPMSOC_HAS_HPMSDK_PDM=y; HPMSOC_HAS_HPMSDK_PWM=y; HPMSOC_HAS_HPMSDK_HALL=y; HPMSOC_HAS_HPMSDK_QEI=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_LCDC=y; HPMSOC_HAS_HPMSDK_CAM=y; HPMSOC_HAS_HPMSDK_PDMA=y; HPMSOC_HAS_HPMSDK_JPEG=y; HPMSOC_HAS_HPMSDK_ENET=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_SDXC=y; HPMSOC_HAS_HPMSDK_CONCTL=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SDP=y; HPMSOC_HAS_HPMSDK_FEMC=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PSEC=y; HPMSOC_HAS_HPMSDK_PMON=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_VAD=y; HPMSOC_HAS_HPMSDK_PLLCTL=y; HPMSOC_HAS_HPMSDK_BPOR=y; HPMSOC_HAS_HPMSDK_BCFG=y; HPMSOC_HAS_HPMSDK_BUTN=y; HPMSOC_HAS_HPMSDK_BGPR=y; HPMSOC_HAS_HPMSDK_RTC=y; HPMSOC_HAS_HPMSDK_BSEC=y; HPMSOC_HAS_HPMSDK_BKEY=y; HPMSOC_HAS_HPMSDK_BMON=y; HPMSOC_HAS_HPMSDK_TAMP=y; HPMSOC_HAS_HPMSDK_MONO=y; HPMSOC_HAS_HPMSDK_PMP=y; CONFIG_MCL_HAS_EXTRA_CONFIG="mcl_app_config.h"
  ICCRISCV.CCIncludePath2: ../../../../../arch; ../../../../../arch/riscv/l1c; ../../../../../arch/riscv/intc; ../../../../../boards/hpm6750evkmini; ../../../../../soc/HPM6700/HPM6750; ../../../../../soc/HPM6700/ip; ../../../../../soc/HPM6700/HPM6750/toolchains; ../../../../../soc/HPM6700/HPM6750/boot; ../../../../../drivers/inc; ../../../../../utils; ../../../../../components/debug_console; ../../../../../components/adc_v2; ../../../../../middleware/hpm_mcl_v2; ../../../../../middleware/hpm_mcl_v2/encoder; ../../../../../middleware/hpm_mcl_v2/drivers; ../../../../../middleware/hpm_mcl_v2/core/sensor; ../../../../../middleware/hpm_mcl_v2/core/drivers; ../../../../../middleware/hpm_mcl_v2/core/loop; ../../../../../middleware/hpm_mcl_v2/core/detect; ../../../../../middleware/hpm_mcl_v2/core/control; ../build_tmp/generated/include; ../../src
  IASMRISCV.AsmIncludePath: as above
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: demo.elf
  ILINK.IlinkConfigDefines: _flash_size=8M; _extram_size=16M; _noncacheable_size=256K
  ILINK.IlinkIcfFile: ..\..\..\..\..\soc\HPM6700\HPM6750\toolchains\iar\flash_xip.icf
  ILINK.IlinkProgramEntryLabel: _start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_MULTICORE=y; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_ADC12=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_CAN=y; HPMSOC_HAS_HPMSDK_WDG=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMA=y; HPMSOC_HAS_HPMSDK_RNG=y; HPMSOC_HAS_HPMSDK_KEYM=y; HPMSOC_HAS_HPMSDK_I2S=y; HPMSOC_HAS_HPMSDK_DAO=y; HPMSOC_HAS_HPMSDK_PDM=y; HPMSOC_HAS_HPMSDK_PWM=y; HPMSOC_HAS_HPMSDK_HALL=y; HPMSOC_HAS_HPMSDK_QEI=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_LCDC=y; HPMSOC_HAS_HPMSDK_CAM=y; HPMSOC_HAS_HPMSDK_PDMA=y; HPMSOC_HAS_HPMSDK_JPEG=y; HPMSOC_HAS_HPMSDK_ENET=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_SDXC=y; HPMSOC_HAS_HPMSDK_CONCTL=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SDP=y; HPMSOC_HAS_HPMSDK_FEMC=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PSEC=y; HPMSOC_HAS_HPMSDK_PMON=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_VAD=y; HPMSOC_HAS_HPMSDK_PLLCTL=y; HPMSOC_HAS_HPMSDK_BPOR=y; HPMSOC_HAS_HPMSDK_BCFG=y; HPMSOC_HAS_HPMSDK_BUTN=y; HPMSOC_HAS_HPMSDK_BGPR=y; HPMSOC_HAS_HPMSDK_RTC=y; HPMSOC_HAS_HPMSDK_BSEC=y; HPMSOC_HAS_HPMSDK_BKEY=y; HPMSOC_HAS_HPMSDK_BMON=y; HPMSOC_HAS_HPMSDK_TAMP=y; HPMSOC_HAS_HPMSDK_MONO=y; HPMSOC_HAS_HPMSDK_PMP=y; CONFIG_MCL_HAS_EXTRA_CONFIG="mcl_app_config.h"; NDEBUG
  group sdk_sample/motor_ctrl/bldc_foc/src
    ../../src/: bldc_foc.c
  group soc/HPM6700/HPM6750
    ../../../../../soc/HPM6700/HPM6750/: system.c hpm_sysctl_drv.c hpm_clock_drv.c hpm_otp_drv.c
  group soc/HPM6700/HPM6750/toolchains
    ../../../../../soc/HPM6700/HPM6750/toolchains/: reset.c trap.c reset.c trap.c
  group soc/HPM6700/HPM6750/toolchains/iar
    ../../../../../soc/HPM6700/HPM6750/toolchains/iar/: startup.s
  group soc/HPM6700/HPM6750/boot
    ../../../../../soc/HPM6700/HPM6750/boot/: hpm_bootheader.c
  group arch/riscv/l1c
    ../../../../../arch/riscv/l1c/: hpm_l1c_drv.c
  group boards/hpm6750evkmini
    ../../../../../boards/hpm6750evkmini/: pinmux.c clock.c board.c
  group drivers/src
    ../../../../../drivers/src/: hpm_uart_drv.c hpm_femc_drv.c hpm_sdp_drv.c hpm_lcdc_drv.c hpm_i2c_drv.c hpm_pmp_drv.c hpm_rng_drv.c hpm_gpio_drv.c hpm_spi_drv.c hpm_pdma_drv.c hpm_wdg_drv.c hpm_dma_drv.c hpm_gptmr_drv.c hpm_pwm_drv.c hpm_pllctl_drv.c hpm_usb_drv.c hpm_rtc_drv.c hpm_acmp_drv.c hpm_i2s_drv.c hpm_dao_drv.c hpm_pdm_drv.c hpm_vad_drv.c hpm_cam_drv.c hpm_can_drv.c hpm_jpeg_drv.c hpm_enet_drv.c hpm_sdxc_drv.c hpm_adc12_drv.c hpm_adc16_drv.c hpm_pcfg_drv.c hpm_ptpc_drv.c hpm_mchtmr_drv.c hpm_qei_drv.c hpm_tamp_drv.c
  group utils
    ../../../../../utils/: hpm_sbrk.c hpm_swap.c hpm_ffssi.c hpm_crc32.c
  group components/debug_console
    ../../../../../components/debug_console/: hpm_debug_console.c
  group components/adc_v2
    ../../../../../components/adc_v2/: hpm_adc_v2.c hpm_adc_v2_port.c
  group middleware/hpm_mcl_v2/encoder
    ../../../../../middleware/hpm_mcl_v2/encoder/: hpm_mcl_abz.c hpm_mcl_uvw.c
  group middleware/hpm_mcl_v2/drivers
    ../../../../../middleware/hpm_mcl_v2/drivers/: hpm_mcl_hw_loop.c
  group middleware/hpm_mcl_v2/core/sensor
    ../../../../../middleware/hpm_mcl_v2/core/sensor/: hpm_mcl_encoder.c hpm_mcl_analog.c
  group middleware/hpm_mcl_v2/core/drivers
    ../../../../../middleware/hpm_mcl_v2/core/drivers/: hpm_mcl_drivers.c
  group middleware/hpm_mcl_v2/core/loop
    ../../../../../middleware/hpm_mcl_v2/core/loop/: hpm_mcl_loop.c hpm_mcl_debug.c
  group middleware/hpm_mcl_v2/core/detect
    ../../../../../middleware/hpm_mcl_v2/core/detect/: hpm_mcl_detect.c
  group middleware/hpm_mcl_v2/core/control
    ../../../../../middleware/hpm_mcl_v2/core/control/: hpm_mcl_control.c hpm_mcl_filter.c hpm_mcl_path_plan.c hpm_mcl_hybrid_ctrl.c
