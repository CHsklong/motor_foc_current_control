# IAR project bldc_foc.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: HPM5361xCBx HPMicro HPM5361xCBx
  General.GHeapSize: 0x4000
  ICCRISCV.IccLang: 2
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCExtraOptions: --diag_suppress Pa089; --diag_suppress Pe236; --diag_suppress Pe188; --diag_suppress Pe546; --diag_suppress Pe111
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_CRC=y; HPMSOC_HAS_HPMSDK_TSNS=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_EWDG=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMAV2=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_MCAN=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_QEIV2=y; HPMSOC_HAS_HPMSDK_QEO=y; HPMSOC_HAS_HPMSDK_MMC=y; HPMSOC_HAS_HPMSDK_PWM=y; HPMSOC_HAS_HPMSDK_RDC=y; HPMSOC_HAS_HPMSDK_PLB=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_SEI=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_SDP=y; HPMSOC_HAS_HPMSDK_SEC=y; HPMSOC_HAS_HPMSDK_MON=y; HPMSOC_HAS_HPMSDK_RNG=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_KEYM=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_DAC=y; HPMSOC_HAS_HPMSDK_OPAMP=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_PLLCTLV2=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_PDGO=y; HPMSOC_HAS_HPMSDK_PMP=y; CONFIG_MCL_HAS_EXTRA_CONFIG="mcl_app_config.h"
  ICCRISCV.CCIncludePath2: ../../../../../arch; ../../../../../arch/riscv/l1c; ../../../../../arch/riscv/intc; ../../../../../boards/hpm5300evk; ../../../../../soc/HPM5300/HPM5361; ../../../../../soc/HPM5300/ip; ../../../../../soc/HPM5300/HPM5361/toolchains; ../../../../../soc/HPM5300/HPM5361/boot; ../../../../../drivers/inc; ../../../../../utils; ../../../../../components/debug_console; ../../../../../components/adc_v2; ../../../../../middleware/hpm_mcl_v2; ../../../../../middleware/hpm_mcl_v2/encoder; ../../../../../middleware/hpm_mcl_v2/drivers; ../../../../../middleware/hpm_mcl_v2/core/sensor; ../../../../../middleware/hpm_mcl_v2/core/drivers; ../../../../../middleware/hpm_mcl_v2/core/loop; ../../../../../middleware/hpm_mcl_v2/core/detect; ../../../../../middleware/hpm_mcl_v2/core/control; ../build_tmp/generated/include; ../../src; ../../src/hal; ../../src/driver; ../../src/sensor; ../../src/motor; ../../src/control; ../../src/debug; ../../src/app
  IASMRISCV.AsmIncludePath: as above
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: demo.elf
  ILINK.IlinkConfigDefines: _flash_size=1M
  ILINK.IlinkIcfFile: ..\..\..\..\..\soc\HPM5300\HPM5361\toolchains\iar\flash_xip.icf
  ILINK.IlinkProgramEntryLabel: _start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_CRC=y; HPMSOC_HAS_HPMSDK_TSNS=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_EWDG=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMAV2=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_MCAN=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_QEIV2=y; HPMSOC_HAS_HPMSDK_QEO=y; HPMSOC_HAS_HPMSDK_MMC=y; HPMSOC_HAS_HPMSDK_PWM=y; HPMSOC_HAS_HPMSDK_RDC=y; HPMSOC_HAS_HPMSDK_PLB=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_SEI=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_SDP=y; HPMSOC_HAS_HPMSDK_SEC=y; HPMSOC_HAS_HPMSDK_MON=y; HPMSOC_HAS_HPMSDK_RNG=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_KEYM=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_DAC=y; HPMSOC_HAS_HPMSDK_OPAMP=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_PLLCTLV2=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_PDGO=y; HPMSOC_HAS_HPMSDK_PMP=y; CONFIG_MCL_HAS_EXTRA_CONFIG="mcl_app_config.h"; NDEBUG
  group sdk_sample/motor_ctrl/bldc_foc/src/hal
    ../../src/hal/: hal_bsp.c
  group sdk_sample/motor_ctrl/bldc_foc/src/driver
    ../../src/driver/: drv_spi.c drv_pwm.c drv_adc.c drv_timer.c drv_qei.c
  group sdk_sample/motor_ctrl/bldc_foc/src/sensor
    ../../src/sensor/: mt6835.c sens_encoder.c sens_analog.c
  group sdk_sample/motor_ctrl/bldc_foc/src/motor
    ../../src/motor/: motor.c motor_hw_foc.c
  group sdk_sample/motor_ctrl/bldc_foc/src/control
    ../../src/control/: ctrl_svpwm.c ctrl_foc.c
  group sdk_sample/motor_ctrl/bldc_foc/src/debug
    ../../src/debug/: dbg_probe.c
  group sdk_sample/motor_ctrl/bldc_foc/src/app
    ../../src/app/: app_monitor.c main.c
  group soc/HPM5300/HPM5361
    ../../../../../soc/HPM5300/HPM5361/: system.c hpm_sysctl_drv.c hpm_clock_drv.c hpm_otp_drv.c hpm_qeiv2_soc_drv.c
  group soc/HPM5300/HPM5361/toolchains
    ../../../../../soc/HPM5300/HPM5361/toolchains/: reset.c trap.c reset.c trap.c
  group soc/HPM5300/HPM5361/toolchains/iar
    ../../../../../soc/HPM5300/HPM5361/toolchains/iar/: startup.s
  group soc/HPM5300/HPM5361/boot
    ../../../../../soc/HPM5300/HPM5361/boot/: hpm_bootheader.c
  group arch/riscv/l1c
    ../../../../../arch/riscv/l1c/: hpm_l1c_drv.c
  group boards/hpm5300evk
    ../../../../../boards/hpm5300evk/: pinmux.c board.c clock.c
  group drivers/src
    ../../../../../drivers/src/: hpm_uart_drv.c hpm_sdp_drv.c hpm_i2c_drv.c hpm_pmp_drv.c hpm_rng_drv.c hpm_gpio_drv.c hpm_spi_drv.c hpm_gptmr_drv.c hpm_pwm_drv.c hpm_pllctlv2_drv.c hpm_usb_drv.c hpm_acmp_drv.c hpm_adc16_drv.c hpm_pcfg_drv.c hpm_ptpc_drv.c hpm_mchtmr_drv.c hpm_tsns_drv.c hpm_dac_drv.c hpm_crc_drv.c hpm_mcan_drv.c hpm_qeiv2_drv.c hpm_enc_pos_drv.c hpm_sei_drv.c hpm_qeo_drv.c hpm_rdc_drv.c hpm_mmc_drv.c hpm_dmav2_drv.c hpm_ewdg_drv.c hpm_plb_drv.c hpm_opamp_drv.c
  group utils
    ../../../../../utils/: hpm_sbrk.c hpm_swap.c hpm_ffssi.c hpm_crc32.c
  group components/debug_console
    ../../../../../components/debug_console/: hpm_debug_console.c
  group components/adc_v2
    ../../../../../components/adc_v2/: hpm_adc_v2.c hpm_adc_v2_port.c
  group middleware/hpm_mcl_v2/encoder
    ../../../../../middleware/hpm_mcl_v2/encoder/: hpm_mcl_abz.c hpm_mcl_uvw.c
  group middleware/hpm_mcl_v2/drivers
    ../../../../../middleware/hpm_mcl_v2/drivers/: hpm_mcl_hw_loop.c
  group middleware/hpm_mcl_v2/core/sensor
    ../../../../../middleware/hpm_mcl_v2/core/sensor/: hpm_mcl_encoder.c hpm_mcl_analog.c
  group middleware/hpm_mcl_v2/core/drivers
    ../../../../../middleware/hpm_mcl_v2/core/drivers/: hpm_mcl_drivers.c
  group middleware/hpm_mcl_v2/core/loop
    ../../../../../middleware/hpm_mcl_v2/core/loop/: hpm_mcl_loop.c hpm_mcl_debug.c
  group middleware/hpm_mcl_v2/core/detect
    ../../../../../middleware/hpm_mcl_v2/core/detect/: hpm_mcl_detect.c
  group middleware/hpm_mcl_v2/core/control
    ../../../../../middleware/hpm_mcl_v2/core/control/: hpm_mcl_control.c hpm_mcl_filter.c hpm_mcl_path_plan.c hpm_mcl_hybrid_ctrl.c
